# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32H750xx
  c include: applications;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\wlan;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\romfs;.;rt-thread\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\net\lwip\port;libraries\samples;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;libraries\rt_ota_lib\inc;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;rt-thread\components\utilities\ulog;rt-thread\components\utilities\ymodem;libraries\wlan_wiced_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\STM32H750XBHx\link.sct
  group Applications
    applications/: hcics_guard.c hcics_motion.c hcics_track.c hcics_rt_compat.c hcics_axis.c main.c hcics_encoder.c hcics_protocol.c hcics_app.c hcics_cleaner.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c-bit-ops.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c workqueue.c ringbuffer.c pipe.c waitqueue.c ringblk_buf.c dataqueue.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c pulse_encoder.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/sdio/: sd.c sdio.c mmcsd_core.c block_dev.c mmc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_flash_sfud.c spi_dev.c spi_core.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/wlan/: wlan_mgnt.c wlan_cfg.c wlan_dev.c wlan_lwip.c wlan_workqueue.c wlan_prot.c
  group Drivers
    board/port/: filesystem.c
    board/: drv_mpu.c board.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_gpio.c drv_sdram.c drv_spi_flash.c drv_sdio.c drv_soft_i2c.c drv_pwm.c drv_spi.c drv_common.c drv_wlan.c drv_lcd.c drv_usart.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal.c fal_rtt.c fal_partition.c
    rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group Kernel
    rt-thread/src/: ipc.c device.c thread.c idle.c irq.c timer.c scheduler.c components.c mempool.c clock.c kservice.c memheap.c object.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: ip4_frag.c ip4_addr.c etharp.c dhcp.c autoip.c ip4.c igmp.c icmp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: stats.c netif.c ip.c pbuf.c inet_chksum.c init.c def.c dns.c memp.c tcp_out.c udp.c sys.c tcp.c timeouts.c raw.c tcp_in.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: sockets.c tcpip.c netifapi.c err.c api_msg.c netbuf.c api_lib.c netdb.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: lowpan6.c ethernet.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/port/: sys_arch.c ethernetif.c
  group rt_ota
    libraries/rt_ota_lib/src/: rtota_update.c
    libraries/rt_ota_lib/libs/: librt_ota_armcm7_noalgo_0.2.3_keil.lib
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_comp.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_cryp.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal.c stm32h7xx_hal_rng.c stm32h7xx_hal_dma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_pwr_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_mdma.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_crc.c stm32h7xx_hal_usart.c stm32h7xx_hal_i2c.c stm32h7xx_hal_pwr.c stm32h7xx_hal_adc.c stm32h7xx_hal_nor.c stm32h7xx_hal_cortex.c stm32h7xx_hal_spi.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ymodem/: ymodem.c
  group WICED
    libraries/wlan_wiced_lib/: libwifi_6212_armcm7_2.1.2_armcc.lib
